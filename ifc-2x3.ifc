Properties of the parts of a building model (IFC2X3)

# File
Description: Einzelne Montage-Klammer, ViewDefinition[CoordinationView]
File name: ifc-2x3.ifc
Time: 2026-04-23T13:34:05+0000
Author: ALRE-IT Regeltechnik GmbH, mail@alre.de
Organization: ALRE-IT Regeltechnik GmbH, Richard-Tauber-Damm 10, 12277 Berlin, +49 30 39984-0, https://alre.de
Written by: 2.0.0
Made in: ALRE-IT BMEcat2IFC Exporter
Authorization: N/A

# IfcBuildingStorey, Geschoss
In: Gebaeude
Elevation: 0 m

# IfcBuildingElementProxy: C1809462, Einzelne Montage-Klammer
In: Raum
Description: Einzelne Montage-Klammer (Metall) für Frostschutzthermostat JTF/RTKSA; Classification: EC011349 ETIM-Klasse (ETIM)
Pset_ManufacturerTypeInformation - Manufacturer: ALRE-IT Regeltechnik GmbH; ModelReference: C1809462; ModelLabel: JZ-05/1M; GlobalTradeItemNumber: 4050528018397; ProductURL: https://alre.de/produkt_C1809462
Pset_Specification - NominalLength: 0.05 m; NominalWidth: 0.036 m; NominalDepth: 0.006 m; NetWeight: 0.009
Pset_ALRE_ETIM_Properties - Art des Zubehörs/Ersatzteils: sonstige; Zubehör: yes; ETIM-Klasse: EC011349; ETIM-Version: ETIM-10.0
Pset_ALRE_Dokumente - Datenblatt: https://media.alre.de/deu_DEU/datasheet/ALRE_Datenblatt-C1809462.pdf
